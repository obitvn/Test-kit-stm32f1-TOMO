<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\NRF24 C8T6 TRANS.ewp</path>
  </project>
  <batchBuild />
</workspace>
